/* Servo */
#include <Servo.h>
Servo myservo;
int pos = 0;    // variable to store the servo position

/* LCD Screen */
#include <LiquidCrystal.h>
const int rs = 12, en  = 11, d4 = 5, d5 = 4, d6 = 3, d7 = 2;
LiquidCrystal lcd(rs, en, d4, d5, d6, d7);

/*  Temperature humidity sensor */
#include <DHT.h>
#define datapin 7     // Digital  pin we're connected to
#define DHTTYPE DHT22
DHT dht(datapin, DHTTYPE);


void  setup() {
  Serial.begin(9600);
  dht.begin(); 
  lcd.begin(16, 2);
  myservo.attach(A0);  // attaches the servo on pin A0 to the servo object
  myservo.write(0); // Start with servo at 0 degrees
}

void loop() {

  /* Find Temperature & Humidity */
  float air_temp = dht.readTemperature();
  float humidity = dht.readHumidity();

  /* Check if reading failed */
  if (isnan(air_temp)) {
    Serial.println("Failed to read from DHT sensor!");
    return;
  }

  /* Print Output on LCD Screen  */
  lcd.setCursor(0,0);
  lcd.print(String("Temp. ") + String(air_temp));
  lcd.setCursor(0,1);
  lcd.print(String("Humidity ") + String(humidity) + String("%"));

  delay(2000);

 // Servo control based on temperature
  myservo.write(0);
  if (air_temp >= 24.0) {
    myservo.write(130); // Move to 130 degrees
  } else if (air_temp <= 23.0) {
    myservo.write(50);   // Move back to 0 degrees
  } 

 /*// Servo control based on  humidity (easier to test)
    myservo.write(0);
  if (humidity >= 50) {
    myservo.write(130); // Move to 130 degrees
  } else if (humidity <= 40) {
    myservo.write(50);   // Move back to 0 degrees
  }
*/
  delay(2000); // Wait a few seconds between readings


}
